# Keil uVision project ElevatorSystem.uvproj, settings and files
target ElevatorSystem (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ElevatorSystem +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLIB\inc;..\CORE;..\USER;..\DRIVER\28BYJ-48;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\ele_run;..\DRIVER\DL_KEY;..\DRIVER\ESP8266;..\DRIVER\FMQ;..\DRIVER\JZ_KEY;..\DRIVER\LCD1602;..\DRIVER\MAX7219;..\DRIVER\RFID_RC52;..\DRIVER\RGB_LED;..\DRIVER\SMG_CGND;..\DRIVER\RELAY;..\DRIVER\S_LIGHT;..\DRIVER\LED_GROUP;..\DRIVER\MATRIX_KEY
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c config.h
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/ele_run/: ele_run.c
    ../SYSTEM/interrupt/: interrput.c
  group DRIVER
    ../DRIVER/28BYJ-48/: 28BYJ-48.c
    ../DRIVER/FMQ/: fmq.c
    ../DRIVER/JZ_KEY/: jz_key.c
    ../DRIVER/RGB_LED/: rgb_led.c
    ../DRIVER/SMG_CGND/: smg.c
    ../DRIVER/RELAY/: relay.c
    ../DRIVER/S_LIGHT/: s_light.c
    ../DRIVER/LED_GROUP/: led_group.c
    ../DRIVER/MAX7219/: max7219.c
    ../DRIVER/LCD1602/: 1602.c
  group FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
