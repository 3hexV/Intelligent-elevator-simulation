# Keil uVision project test.uvproj, settings and files
target rc522_test (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\mcu\core;..\startup;..\user\systick;..\user;..\mcu\system;..\user\usart;..\mcu\gpio;..\mcu\rcc;..\mcu\usart;..\user\rc522;..\mcu\it
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: main.c rc522_test.c jz_key.c
    ../user/rc522/: rc522_config.c rc522_function.c
    ../user/usart/: usart.c
    ../user/systick/: user_SysTick.c
  group mcu
    ../mcu/core/: core_cm3.c
    ../mcu/system/: system_stm32f10x.c
    ../mcu/gpio/: stm32f10x_gpio.c
    ../mcu/rcc/: stm32f10x_rcc.c
    ../mcu/usart/: stm32f10x_usart.c
    ../mcu/it/: stm32f10x_it.c
  group startup
    ../startup/: startup_stm32f10x_hd.s
